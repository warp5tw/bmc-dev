FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://bluewhale-npcm7xx.cfg"

